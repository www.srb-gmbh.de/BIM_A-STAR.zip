Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 2018_01
Time: 2022-09-01T13:52:36+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternativ-UI 23.0.11.19

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: A-STAR EQ-R:A-STAR EQ-R - 280 lm - Zentralbatterie, A-STAR EQ-R:A-STAR EQ-R - 280 lm - Zentralbatterie:2487267
In: Default
Type - Material: Aluminium Druckguss - RAL9016, Kunststoff -PVC, Weiß_1
Type - Pset_ElementShading - Color: white
Material: Weiß_1
Pset_DistributionFlowElementCommon - Reference: A-STAR EQ-R - 280 lm - Zentralbatterie; sets with these values: 2
